# Keil uVision project GN_AT32F437.uvprojx, settings and files
target Generator_Boot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.2
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GNP_AT32F437 +hex
  AfterMake: fromelf --bin -o .\Generator_CB_V2.x.x.bin     .\OBJ\objs\GNP_AT32F437.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F437ZGT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,ARM_MATH_CM4,BOOT
  c include: .\RTE;.\RTE\PrjLib;.\SDK\libraries\drivers\inc;.\SDK\libraries\cmsis\cm4\core_support;.\SDK\libraries\cmsis\cm4\device_support;.\SDK\middlewares\freertos\source\include;.\SDK\middlewares\freertos\source\portable\memmang;.\SDK\middlewares\freertos\source\portable\rvds\ARM_CM4F;.\SDK\middlewares\FlashDB\inc;.\SDK\middlewares\FlashDB\port\fal\inc;.\HAL\BSP_At24c256;.\HAL\BSP_Board;.\HAL\BSP_Dac5614;.\HAL\BSP_Gpio;.\HAL\BSP_FpgaUnit;.\HAL\BSP_Flash;.\HAL\BSP_DS1339;.\HAL\BSP_ad7689;.\HAL\HAL_Cfg;.\HAL\MCU_Adc;.\HAL\MCU_Dac;.\HAL\MCU_Flash;.\HAL\MCU_Gpio;.\HAL\MCU_Tmr;.\HAL\MCU_Uart;.\HAL\MCU_Wdog;.\SL\Comm;.\SL\Comm\fgipv2;.\SL\Comm\csipv1;.\SL\Sensor;.\SL\Nvm;.\SL\Timer;.\SL\Boot;.\SL\SL_Cfg;.\APP\PT_SWC;.\APP\HwTest_SWC;.\SDK\middlewares\FlashDB\sfud\inc;.\SDK\middlewares\FlashDB\sfud\port;.\SDK\middlewares\FlashDB\port\fal\samples\porting;.\SL\Interface;.\SL\Comm\modus;.\SL\Comm\bsipv1;.\SDK\middlewares\FREEMODBUS\modbus\include;.\SDK\middlewares\FREEMODBUS\port;.\SDK\middlewares\FREEMODBUS\port\rtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group APP
    ./APP/PT_SWC/: PT_SWC.c PT_ModuleInput.c PT_ModuleOutput.c
  group HAL
    ./HAL/BSP_Board/: at32f435_437_clock.c at32f435_437_int.c Board.c
    ./HAL/BSP_At24c256/: At24c256.c
    ./HAL/BSP_Dac5614/: Dac5614.c
    ./HAL/BSP_Gpio/: IO_Gpio.c
    ./HAL/BSP_FpgaUnit/: FpgaUnit.c
    ./HAL/HAL_Cfg/: HAL_Cfg.c
    ./HAL/MCU_Adc/: Adc.c
    ./HAL/MCU_Flash/: Flash.c
    ./HAL/MCU_Gpio/: Gpio.c
    ./HAL/MCU_Tmr/: Tmr.c
    ./HAL/MCU_Uart/: Uart.c
    ./HAL/MCU_Wdog/: Wdog.c
    ./HAL/BSP_AD7689/: AD7689.c
    ./HAL/BSP_Flash/: MX25L128.c
    ./HAL/BSP_DS1339/: Ds1339.c
  group RTE
    ./RTE/: main.c configDevice.h FreeRTOSConfig.h
    ./RTE/PrjLib/: PrjLib.c arm_cortexM4lf_math.lib
    ./: README.md
  group SL
    ./SL/SL_Cfg/: SL_Cfg.c
    ./SL/Comm/: Comm.c
    ./SL/Nvm/: Nvm.c params_impl.c
    ./SL/Sensor/: Sensor.c DevSensor.c FpgaSensor.c
    ./SL/Timer/: Timer.c
    ./SL/Comm/fgipv2/: fgipv2_layer2.c fgipv2_layer7.c pppfcs.c stm32_crc32.c
    ./SL/Boot/: Boot.c
    ./SL/Interface/: Interface.c
    ./SL/Comm/modus/: ModBus.c
    ./SL/Comm/bsipv1/: bsip_layer2.c bsip_layer2.h bsip_layer7.c bsip_layer7.h
    ./SL/log/: tsdb_log.c
  group SDK
    ./SDK/libraries/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
    ./SDK/middlewares/freertos/source/portable/rvds/ARM_CM4F/: port.c
    ./SDK/middlewares/freertos/source/portable/memmang/: heap_4.c
    ./SDK/middlewares/freertos/source/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
    ./SDK/libraries/cmsis/cm4/device_support/: system_at32f435_437.c
    ./SDK/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
  group FLASHDB
    ./SDK/middlewares/FlashDB/src/: fdb.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c drv_spi_flash.c
    ./SDK/middlewares/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ./SDK/middlewares/FlashDB/port/fal/samples/porting/: fal_flash_sfud_port.c
    ./SDK/middlewares/FlashDB/sfud/src/: sfud.c sfud_sfdp.c
    ./SDK/middlewares/FlashDB/sfud/port/: sfud_port.c
target Generator_App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F437ZGT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.2
  cpu: as above
  output: GNP_AT32F437 +hex
  AfterMake: fromelf --bin -o .\Generator_AT32F437.bin    .\OBJ\objs\GNP_AT32F437.axf
  AfterMake: Encryptor CY_GN017 1 Generator_AT32F437.bin GN017_CA_AppPacked_V2.x.x.bin
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F437ZGT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_ROUNDING
  c include: .\RTE;.\RTE\PrjLib;.\SDK\libraries\drivers\inc;.\SDK\libraries\cmsis\cm4\core_support;.\SDK\libraries\cmsis\cm4\device_support;.\SDK\middlewares\freertos\source\include;.\SDK\middlewares\freertos\source\portable\memmang;.\SDK\middlewares\freertos\source\portable\rvds\ARM_CM4F;.\HAL\BSP_A3979;.\HAL\BSP_At24c256;.\HAL\BSP_Board;.\HAL\BSP_Dac5614;.\HAL\BSP_Gpio;.\HAL\BSP_DS1339;.\HAL\BSP_FpgaUnit;.\HAL\BSP_Flash;.\HAL\HAL_Cfg;.\HAL\MCU_Adc;.\HAL\MCU_Dac;.\HAL\MCU_Flash;.\HAL\MCU_Gpio;.\HAL\MCU_Tmr;.\HAL\MCU_Uart;.\HAL\MCU_Wdog;.\SL\Motor;.\SL\Comm;.\SL\Comm\fgipv2;.\SL\Sensor;.\SL\Nvm;.\SL\Timer;.\SL\Interface;.\SL\Boot;.\SL\SL_Cfg;.\APP\PT_SWC;.\APP\HwTest_SWC;.\HAL\BSP_AD7689;.\HAL\MCU_Key;.\SL\Key;.\SL\Lcd;.\SL\Comm\modus;.\SL\Comm\csipv1;.\SL\Comm\bsipv1;.\SDK\middlewares\FlashDB\inc;.\SDK\middlewares\FlashDB\sfud\inc;.\SDK\middlewares\FlashDB\port\fal\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8032200 size 0x31e00
  memory RVCT9: RAM 0x20000000 size 0x60000
